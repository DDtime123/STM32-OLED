# Keil uVision project OLED96.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Flibrary\inc;..\startup;..\user;..\user\api;..\user\api\myiic;..\user\api\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
  group api
    ../user/api/: delay.c delay.h iic.c iic.h io_bit.h oled.c oled.h font.c font.h
  group startup
    ../startup/: startup_stm32f10x_md.s
  group Flibrary
    ../Flibrary/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group AHT20
    ../user/api/myiic/: bsp_i2c.c bsp_i2c.h delay2.c delay2.h
    ../user/api/usart/: sys.c sys.h usart.c usart.h
software components: CMSIS:CORE 4.3.0
